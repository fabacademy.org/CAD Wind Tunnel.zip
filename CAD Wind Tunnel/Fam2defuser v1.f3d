Fam2defuser v1 (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "defuser holder"