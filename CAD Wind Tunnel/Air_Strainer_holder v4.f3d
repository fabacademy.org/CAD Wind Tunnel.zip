Air_Strainer_holder v4 (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Airstrinder Holder"