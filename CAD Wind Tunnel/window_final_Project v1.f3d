window_final_Project v1 (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "window"